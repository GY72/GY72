# Keil uVision project MB022_1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH79F328 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(24000000)
  output: GY_MB_MN_K2205 +hex
  c flags: Optimize=8 SizeSpeed=1
  group bsp
    ../src/bsp/: inputs.c interrupt_s.c mcu.c outputs.c gesture.c display.c
  group src
    ../src/: main.c system.c
  group lib
    ../src/lib/: app_timer.c buzzer.c key_v2.3.c key_v2.3_lib.c misc.c tm1640.c uart.c protocol.c handgesture.c tm16xx.c eeprom.c
  group sino_touchkey
    ../src/sino_touchkey/Lib/: sino_tk_isr.c
    ../src/sino_touchkey/Inc/: tk_conf_add.h
    ../src/sino_touchkey/Lib_Src/: TouchKey_JHB_Large_V5.2.LIB
